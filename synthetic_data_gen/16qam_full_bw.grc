options:
  parameters:
    generate_options: no_gui
    id: data_gen_16qam_full_bw
    output_language: python
    title: 16QAM full bandwidth
  states: {}

blocks:
- name: sig1_bw
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: 16qam_full_bw.bin
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Base Sampling Rate
    type: eng_float
    value: 2.0e6
  states: {}
- name: signal_16qam_0
  id: signal_16qam
  parameters:
    offset_freq: '0'
    samp_rate: samp_rate
    signal_bandwidth: sig1_bw
  states: {}

connections:
- [blocks_throttle_0_0, '0', blocks_file_sink_0, '0']
- [signal_16qam_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
