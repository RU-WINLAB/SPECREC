options:
  parameters:
    author: root
    generate_options: no_gui
    id: data_gen
    output_language: python
    title: Synthetic Data Generation
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file.bin
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: signal_16qam_0
  id: signal_16qam
  parameters:
    offset_freq: 1e6
    samp_rate: 20e6
    signal_bandwidth: 2.5e6
  states: {}
- name: signal_QPSK_0
  id: signal_QPSK
  parameters:
    offset_freq: 7e6
    samp_rate: 20e6
    signal_bandwidth: 1.5e6
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0_0, '0', blocks_add_xx_0, '0']
- [signal_16qam_0, '0', blocks_throttle_0, '0']
- [signal_QPSK_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
