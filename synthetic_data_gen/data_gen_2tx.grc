options:
  parameters:
    author: root
    generate_options: no_gui
    id: data_gen_2tx
    output_language: python
    run_options: run
    title: Generic Dual Transmitter Data Gen
  states: {}

blocks:
- name: mod_bps
  id: variable
  parameters:
    value: 1 if modulation1 == "bpsk" else 2 if modulation1 == "cpm" else 1 if modulation1 == "gmsk" else 2 if modulation1 == "qpsk" else 4 if modulation1 == "16qam" else 3
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: 50/(10**(snr/20)) * sig1_bw * mod_bps/samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: '''cleansig1_'' + filename'
    type: complex
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: '''cleansig2_'' + filename'
    type: complex
  states: {}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: num_samps
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain2
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_voltage
    seed: noise_seed
    taps: 1.0 + 1.0j
  states: {}
- name: filename
  id: parameter
  parameters:
    label: Filename
    type: str
    value: file1.bin
  states: {}
- name: gain1
  id: parameter
  parameters:
    label: Gain for signal 1
    type: eng_float
    value: '1'
  states: {}
- name: gain2
  id: parameter
  parameters:
    label: Gain for signal 2
    type: eng_float
    value: '1'
  states: {}
- name: modulation1
  id: parameter
  parameters:
    label: Modulation type ('bpsk', 'cpm', 'gmsk', 'qpsk', '16qam', 8psk')
    type: str
    value: bpsk
  states: {}
- name: modulation2
  id: parameter
  parameters:
    label: Modulation type ('bpsk', 'cpm', 'gmsk', 'qpsk', '16qam', 8psk')
    type: str
    value: 16qam
  states: {}
- name: noise_seed
  id: parameter
  parameters:
    label: Noise seed
    type: intx
    value: '0'
  states: {}
- name: num_samps
  id: parameter
  parameters:
    label: Number of samples
    type: intx
    value: '1000000'
  states: {}
- name: one_tx_0
  id: one_tx
  parameters:
    modulation: modulation1
    samp_rate: samp_rate
    sig_bw: sig1_bw
    sig_freq: sig1_freq
  states: {}
- name: one_tx_0_0
  id: one_tx
  parameters:
    modulation: modulation2
    samp_rate: samp_rate
    sig_bw: sig2_bw
    sig_freq: sig2_freq
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: Base Sampling Rate
    type: eng_float
    value: 20e6
  states: {}
- name: sig1_bw
  id: parameter
  parameters:
    label: Bandwidth of the Signal
    type: eng_float
    value: 4e6
  states: {}
- name: sig1_freq
  id: parameter
  parameters:
    label: Central Frequency of the Signal
    type: eng_float
    value: 7e6
  states: {}
- name: sig2_bw
  id: parameter
  parameters:
    label: Bandwidth of the Signal
    type: eng_float
    value: 3e6
  states: {}
- name: sig2_freq
  id: parameter
  parameters:
    label: Central Frequency of the Signal
    type: eng_float
    value: '-2e6'
  states: {}
- name: snr
  id: parameter
  parameters:
    label: Signal to Noise Ratio
    type: eng_float
    value: '50'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_head_1, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_file_sink_1_0, '0']
- [blocks_throttle_0_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', blocks_head_1, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [one_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [one_tx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
