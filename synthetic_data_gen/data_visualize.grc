options:
  parameters:
    author: root
    generate_options: qt_gui
    id: data_visualize
    output_language: python
    title: Synthetic Data Visualization
  states: {}

blocks:
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.1'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Base Sampling Rate
    value: 100e6
  states: {}
- name: signal_16qam_0
  id: signal_16qam
  parameters:
    offset_freq: 1e6
    samp_rate: samp_rate
    signal_bandwidth: 5e6
  states: {}
- name: signal_QPSK_0
  id: signal_QPSK
  parameters:
    offset_freq: 7e6
    samp_rate: samp_rate
    signal_bandwidth: 1.5e6
  states: {}
- name: signal_QPSK_0_0
  id: signal_QPSK
  parameters:
    offset_freq: '-5e6'
    samp_rate: samp_rate
    signal_bandwidth: 3e6
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_add_xx_0_0, '0']
- [blocks_add_xx_0_0, '0', channels_channel_model_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0_0, '0', blocks_add_xx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [signal_16qam_0, '0', blocks_throttle_0, '0']
- [signal_QPSK_0, '0', blocks_throttle_0_0, '0']
- [signal_QPSK_0_0, '0', blocks_add_xx_0_0, '1']

metadata:
  file_format: 1
