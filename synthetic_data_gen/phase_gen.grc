options:
  parameters:
    author: tld95
    description: This module will be used to generate a contant phase shifft in one direction
    generate_options: qt_gui
    id: phase_gen
    output_language: python
    title: phase_gen
  states: {}

blocks:
- name: freq_adj
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1000000'
    value: '1000'
    widget: counter
  states: {}
- name: mod_selector
  id: variable_qtgui_chooser
  parameters:
    label: mod_selector
    label0: bpsk
    label1: qpsk
    label2: 8psk
    label3: 16qam
    num_opts: '4'
    option1: qpsk
    option2: 8psk
    option3: 16qam
    options: '[bpsk, qpsk, 8psk, 16qam]'
    type: string
    value: bpsk
  states: {}
- name: phase_amp
  id: variable
  parameters:
    value: '.1'
  states: {}
- name: var_phase_amp_adj
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '10'
    value: '.5'
  states: {}
- name: var_sine_freq_adj
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '.001'
    stop: '1'
    value: '.5'
  states: {}
- name: wave_freq
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: var_sine_freq_adj
    offset: '0'
    phase: '0'
    samp_rate: '1000'
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: var_phase_amp_adj
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: cos
    type: float
  states: {}
- name: blocks_transcendental_0_0
  id: blocks_transcendental
  parameters:
    name: sin
    type: float
  states: {}
- name: one_tx_0
  id: one_tx
  parameters:
    modulation: mod_selector
    samp_rate: freq_adj
    sig_bw: freq_adj
    sig_freq: 7e6
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {state: disabled}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '100'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_transcendental_0, '0', blocks_float_to_complex_0, '0']
- [blocks_transcendental_0_0, '0', blocks_float_to_complex_0, '1']
- [one_tx_0, '0', blocks_multiply_xx_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
