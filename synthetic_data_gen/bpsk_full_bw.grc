options:
  parameters:
    author: root
    generate_options: no_gui
    id: data_gen_bpsk_full_bw
    output_language: python
    title: BPSK full bandwidth
  states: {}

blocks:
- name: sig1_bw
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bpsk_full_bw.bin
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: filename
  id: parameter
  parameters:
    label: Filename
    type: str
    value: file1.bin
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Base Sampling Rate
    type: eng_float
    value: 2.0e6
  states: {}
- name: signal_bpsk_0
  id: signal_bpsk
  parameters:
    offset_freq: '0'
    samp_rate: samp_rate
    signal_bandwidth: sig1_bw
  states: {}

connections:
- [blocks_throttle_0_0, '0', blocks_file_sink_0, '0']
- [signal_bpsk_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
