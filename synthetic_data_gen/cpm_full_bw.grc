options:
  parameters:
    generate_options: no_gui
    id: data_gen_cpm_full_bw
    output_language: python
    title: CPM full bandwidth
  states: {}

blocks:
- name: sig1_bw
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: cpm_full_bw.bin
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Base Sampling Rate
    type: eng_float
    value: 2.0e6
  states: {}
- name: signal_cpm_0
  id: signal_cpm
  parameters:
    offset_freq: 5e6
    samp_rate: 20e6
    signal_bandwidth: 5e6
  states: {}

connections:
- [blocks_throttle_0_0, '0', blocks_file_sink_0, '0']
- [signal_cpm_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
