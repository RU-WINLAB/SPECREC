options:
  parameters:
    generate_options: hb
    id: signal_16qam_filesource
    output_language: python
    title: 16QAM signal filesource
  states: {}

blocks:
- name: run_time
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: source_file
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_0
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: offset_freq
  id: parameter
  parameters:
    label: Signal Central Frequency
    value: 5e6
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(signal_bandwidth)
    interp: int(samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Baseband Sampling Rate
    value: 20e6
  states: {}
- name: signal_bandwidth
  id: parameter
  parameters:
    label: Signal Bandwidth
    value: 5e6
  states: {}
- name: source_file
  id: parameter
  parameters:
    label: Source File Name
    type: str
    value: sourcefile.bin
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', digital_constellation_modulator_0, '0']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [digital_constellation_modulator_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
