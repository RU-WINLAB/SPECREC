options:
  parameters:
    author: root
    generate_options: qt_gui
    id: snr_additive
    output_language: python
    run_options: run
    title: SNR With Additive Noise
  states: {}

blocks:
- name: mod_bps
  id: variable
  parameters:
    value: 1 if modulation == "bpsk" else 2 if modulation == "cpm" else 1 if modulation == "gmsk" else 2 if modulation == "qpsk" else 4 if modulation == "16qam" else 3
  states: {}
- name: signal_gain
  id: variable
  parameters:
    value: 10 ** (snr / 20) * 0.5
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: noise_seed
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: '''cleansig_'' + filename'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: '''noise_'' + filename'
    type: complex
  states: {state: disabled}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: num_samps
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: signal_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.0'
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_amp_bal_0
  id: channels_amp_bal
  parameters:
    alpha: '1'
  states: {}
- name: filename
  id: parameter
  parameters:
    label: Filename
    type: str
    value: file1.bin
  states: {}
- name: modulation
  id: parameter
  parameters:
    label: Modulation type ('bpsk', 'cpm', 'gmsk', 'qpsk', '16qam', 8psk')
    type: str
    value: bpsk
  states: {}
- name: noise_gain
  id: parameter
  parameters:
    label: Noise gain
    type: eng_float
    value: '1.0'
  states: {state: disabled}
- name: noise_seed
  id: parameter
  parameters:
    label: noise seed
    type: intx
    value: '1'
  states: {}
- name: num_samps
  id: parameter
  parameters:
    label: Number of samples
    type: intx
    value: '1000'
  states: {}
- name: one_tx_0
  id: one_tx
  parameters:
    modulation: modulation
    samp_rate: samp_rate
    sig_bw: samp_rate
    sig_freq: '0'
  states: {}
- name: one_tx_filesource_0
  id: one_tx_filesource
  parameters:
    modulation: modulation
    samp_rate: samp_rate
    sig_bw: samp_rate
    sig_freq: '0'
    sourcefile: sourcefile
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Real
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Imag
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Base Sampling Rate
    type: eng_float
    value: 20e6
  states: {}
- name: sig1_bw
  id: parameter
  parameters:
    label: Bandwidth of the Signal
    type: eng_float
    value: 4e6
  states: {state: disabled}
- name: sig1_freq
  id: parameter
  parameters:
    label: Central Frequency of the Signal
    type: eng_float
    value: 7e6
  states: {state: disabled}
- name: signal_gain
  id: parameter
  parameters:
    label: Signal gain (use value lower than 1 for attenuation)
    type: eng_float
    value: '1.0'
  states: {state: disabled}
- name: snr
  id: parameter
  parameters:
    label: Signal to Noise Ratio
    type: eng_float
    value: '100'
  states: {}
- name: sourcefile
  id: parameter
  parameters:
    label: Source Filename
    type: str
    value: source.bin
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_head_1, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_number_sink_0_0, '0']
- [blocks_head_1, '0', blocks_complex_to_float_0, '0']
- [blocks_head_1, '0', channels_amp_bal_0, '0']
- [blocks_head_1, '0', qtgui_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_file_sink_1_0, '0']
- [blocks_throttle_0_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0_0, '0', blocks_file_sink_1, '0']
- [channels_amp_bal_0, '0', blocks_file_sink_0, '0']
- [one_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [one_tx_0, '0', qtgui_sink_x_0, '0']
- [one_tx_filesource_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
