options:
  parameters:
    author: tld95
    generate_options: qt_gui
    id: test_mods
    output_language: python
    title: test_mods
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_phase_noise_gen_0
  id: channels_phase_noise_gen
  parameters:
    alpha: '0'
    noise_mag: '0'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: signal_bpsk_0
  id: signal_bpsk
  parameters:
    offset_freq: '0'
    samp_rate: 20e6
    signal_bandwidth: 5e6
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', channels_phase_noise_gen_0, '0']
- [blocks_throttle_0_0, '0', qtgui_const_sink_x_0, '0']
- [channels_phase_noise_gen_0, '0', blocks_throttle_0_0, '0']
- [signal_bpsk_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
