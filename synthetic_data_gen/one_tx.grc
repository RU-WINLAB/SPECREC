options:
  parameters:
    author: root
    generate_options: hb
    id: one_tx
    output_language: python
    run_options: run
    title: Modulation Tx
  states: {}

blocks:
- name: mod_index
  id: variable
  parameters:
    value: 0 if modulation == "bpsk" else 1 if modulation == "cpm" else 2 if modulation == "gmsk" else 3 if modulation == "qpsk" else 4 if modulation == "16qam" else 5
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mod_index
    num_inputs: '6'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: modulation
  id: parameter
  parameters:
    label: Modulation type ('bpsk', 'cpm', 'gmsk', 'qpsk', '16qam', 8psk')
    type: str
    value: bpsk
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Base Sampling Rate
    type: eng_float
    value: 20e6
  states: {}
- name: sig_bw
  id: parameter
  parameters:
    label: Bandwidth of the Signal
    type: eng_float
    value: 4e6
  states: {}
- name: sig_freq
  id: parameter
  parameters:
    label: Central Frequency of the Signal
    type: eng_float
    value: 7e6
  states: {}
- name: signal_16qam_0
  id: signal_16qam
  parameters:
    offset_freq: sig_freq
    samp_rate: samp_rate
    signal_bandwidth: sig_bw
  states: {}
- name: signal_8psk_0
  id: signal_8psk
  parameters:
    offset_freq: sig_freq
    samp_rate: samp_rate
    signal_bandwidth: sig_bw
  states: {}
- name: signal_QPSK_0
  id: signal_QPSK
  parameters:
    offset_freq: sig_freq
    samp_rate: samp_rate
    signal_bandwidth: sig_bw
  states: {}
- name: signal_bpsk_0
  id: signal_bpsk
  parameters:
    offset_freq: sig_freq
    samp_rate: samp_rate
    signal_bandwidth: sig_bw
  states: {}
- name: signal_cpm_0
  id: signal_cpm
  parameters:
    offset_freq: sig_freq
    samp_rate: samp_rate
    signal_bandwidth: sig_bw
  states: {}
- name: signal_gmsk_0
  id: signal_gmsk
  parameters:
    offset_freq: sig_freq
    samp_rate: samp_rate
    signal_bandwidth: sig_bw
  states: {}

connections:
- [blocks_selector_0, '0', pad_sink_0, '0']
- [signal_16qam_0, '0', blocks_selector_0, '4']
- [signal_8psk_0, '0', blocks_selector_0, '5']
- [signal_QPSK_0, '0', blocks_selector_0, '3']
- [signal_bpsk_0, '0', blocks_selector_0, '0']
- [signal_cpm_0, '0', blocks_selector_0, '1']
- [signal_gmsk_0, '0', blocks_selector_0, '2']

metadata:
  file_format: 1
