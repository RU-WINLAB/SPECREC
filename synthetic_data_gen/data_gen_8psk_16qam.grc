options:
  parameters:
    author: root
    generate_options: no_gui
    id: data_gen_8psk_16qam
    output_language: python
    title: Synthetic Data Generation
  states: {}

blocks:
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: filename
  id: parameter
  parameters:
    label: Filename
    type: str
    value: file1.bin
  states: {}
- name: noise_voltage
  id: parameter
  parameters:
    label: Noise Voltage
    type: eng_float
    value: '0.150'
  states: {}
- name: run_time
  id: parameter
  parameters:
    label: Running time in seconds
    value: '1.0'
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: Base Sampling Rate
    type: eng_float
    value: 20e6
  states: {}
- name: sig1_bw
  id: parameter
  parameters:
    label: Bandwidth of Signal 1
    type: eng_float
    value: 1.5e6
  states: {}
- name: sig1_freq
  id: parameter
  parameters:
    label: Central Frequency of Signal 1
    type: eng_float
    value: 7e6
  states: {}
- name: sig2_bw
  id: parameter
  parameters:
    label: Bandwidth of Signal 2
    type: eng_float
    value: 4e6
  states: {}
- name: sig2_freq
  id: parameter
  parameters:
    label: Central Frequency of Signal 2
    type: eng_float
    value: '-5e6'
  states: {}
- name: signal_16qam_0
  id: signal_16qam
  parameters:
    offset_freq: sig2_freq
    samp_rate: samp_rate
    signal_bandwidth: sig2_bw
  states: {}
- name: signal_8psk_0
  id: signal_8psk
  parameters:
    offset_freq: sig1_freq
    samp_rate: samp_rate
    signal_bandwidth: sig1_bw
  states: {}

connections:
- [blocks_add_xx_0, '0', channels_channel_model_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0_0, '0', blocks_add_xx_0, '0']
- [channels_channel_model_0, '0', blocks_file_sink_0, '0']
- [signal_16qam_0, '0', blocks_throttle_0, '0']
- [signal_8psk_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
