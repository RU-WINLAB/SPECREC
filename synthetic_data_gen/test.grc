options:
  parameters:
    author: tld95
    generate_options: qt_gui
    id: phase_sample
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: digital_cpmmod_bc_0
  id: digital_cpmmod_bc
  parameters:
    L: '4'
    mod_index: '0.5'
    samples_per_symbol: '4'
    type: analog.cpm.GAUSSIAN
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: signal_bpsk_0
  id: signal_bpsk
  parameters:
    offset_freq: '0'
    samp_rate: '1000'
    signal_bandwidth: '1000'
  states: {}

connections:
- [digital_cpmmod_bc_0, '0', qtgui_sink_x_0, '0']
- [signal_bpsk_0, '0', digital_cpmmod_bc_0, '0']

metadata:
  file_format: 1
